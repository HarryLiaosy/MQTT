# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TCP发送数据 +hex
  c flags: Optim=1
  c include: ..\USER;..\LIB\inc;..\CMSIS;..\BSP\LED;..\BSP\SysTick;..\BSP\Key;..\BSP\USART;..\BSP\TIMER;..\MQTT;..\CJSON
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/USART/: usart.c
    ../BSP/Key/: key.c
    ../BSP/LED/: Led.c
    ../BSP/SysTick/: SysTick.c
    ../BSP/TIMER/: timer.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_md.s
  group MQTT
    ../MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group CJSON
    ../CJSON/: cJSON.c
